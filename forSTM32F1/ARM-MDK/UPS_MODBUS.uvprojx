# Keil uVision project UPS_MODBUS.uvprojx, settings and files
target MODBUS (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x +hex
  AfterMake: fromelf --bin --output .\output\STM32F10x.bin  .\obj\STM32F10x.axf
  c flags: Optim=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\uCOS\Ports;..\uCOS\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUP
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group APP
    ../APP/: main.c stm32f10x_it.c Mylib.c APP.c DataSource.c driver.c
  group ucos
    ../uCOS/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
    ../uCOS/Source/: os_core.c os_sem.c os_task.c os_time.c os_tmr.c os_mbox.c
  group BSP
    ../BSP/: BSP.c
  group Lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_usart.c
